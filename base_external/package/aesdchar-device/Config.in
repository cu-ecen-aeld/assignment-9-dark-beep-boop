## base_external/package/aesdchar-device/Config.in
```kconfig
config BR2_PACKAGE_AESDCHAR_DEVICE
	bool "aesdchar-device"
	help
	  Includes the aesdchar device driver.
```
